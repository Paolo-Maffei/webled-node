# IAR project WifiLED.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F10xxE ST STM32F10xxE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ..\Bsp; ..\System; ..\Drivers\Console; ..\Drivers\FWLib\Inc; ..\Drivers\GSPI; ..\Drivers\IntFlash; ..\Drivers\LED; ..\Drivers\KEY; ..\Drivers\Uart; ..\Drivers\Wifi\IF; ..\Drivers\Wifi\IO; ..\Drivers\Wifi\WLAN; ..\Drivers\Wifi\Inc; ..\Drivers\Wifi\Api; ..\Include; ..\APP; ..\Net; ..\Net\uIP_1_0\uip; ..\Net\uIP_1_0\apps\webserver; ..\Net\uIP_1_0\apps\dhcpc; ..\Net\uIP_1_0\apps\webled_udp; ..\Net\uIP_1_0\lib; ..\Net\uIP_1_0\unix; ..\uCOS\core; ..\uCOS\iar_port
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: WifiLED.hex
  ILINK.IlinkOutputFile: WifiLED.out
  ILINK.IlinkIcfFile: lnkarm_flash_stm32f103vet6.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group APP
    ../APP/: AppTask.c AppTask.h Group.c Group.h Main.c module_test.c myMisc.c myMisc.h NodeAttr.c NodeAttr.h uIP_TASK.c uIP_TASK.h
  group Bsp
    ../Bsp/: core_cm3.c core_cm3.h hw_config.c hw_config.h stm32f10x.h stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h system_stm32f10x.c system_stm32f10x.h UartTrace.c UartTrace.h
  group Drivers/Console
    ../Drivers/Console/: Console.c Console.h
  group Drivers/FWLib/inc
    ../Drivers/FWLib/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
  group Drivers/FWLib/src
    ../Drivers/FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Drivers/GSPI
    ../Drivers/GSPI/: GSPI.c GSPI.h
  group Drivers/IntFlash
    ../Drivers/IntFlash/: EEPROM.c EEPROM.h Flash.c Flash.h
  group Drivers/KEY
    ../Drivers/KEY/: KEY.c KEY.h
  group Drivers/LED
    ../Drivers/LED/: LED.c LED.h
  group Drivers/Uart
    ../Drivers/Uart/: Uart.c Uart.h
  group Drivers/Wifi/Api
    ../Drivers/Wifi/Api/: WifiApiExport.c WifiApiExport.h WifiApiPrivate.c WifiApiPrivate.h WiFiCommand.c WIFICommand.h
  group Drivers/Wifi/IF
    ../Drivers/Wifi/IF/: Firmware.h gspi8385.h gspi8686_09mod.h helper8385.h helper_09mod.h Wifi_If.c Wifi_If.h Wifi_If_Gspi.h
  group Drivers/Wifi/Inc
    ../Drivers/Wifi/Inc/: WifiDefs.h
  group Drivers/Wifi/IO
    ../Drivers/Wifi/IO/: Wifi_Hw.c Wifi_Hw.h
  group Drivers/Wifi/WLAN
    ../Drivers/Wifi/WLAN/: MrvConstant.h MrvHostCmd.h MrvStruct.h Ndis.h Ndisdef.h WlanAdapter.c WlanAdapter.h WlanCmd.c WlanCmd.h WlanInit.c WlanInit.h WlanMisc.c WlanMisc.h WlanPkt.c WlanPkt.h
  group EWARM
    ./: startup_stm32f10x_hd.s
  group Include
    ../Include/: app_cfg.h BaseDefs.h BaseTypes.h OS.h os_cfg.h Project.h WifiCfg.h WifiUser.h
  group Net/uIP_1_0/apps/dhcpc
    ../Net/uIP_1_0/apps/dhcpc/: dhcpc.c dhcpc.h
  group Net/uIP_1_0/apps/webled_udp
    ../Net/uIP_1_0/apps/webled_udp/: webled_udp.c webled_udp.h
  group Net/uIP_1_0/apps/webserver
    ../Net/uIP_1_0/apps/webserver/: http-strings.c http-strings.h httpd-cgi.c httpd-cgi.h httpd-fs.c httpd-fs.h httpd-fsdata.h httpd.c httpd.h webserver.h
  group Net/uIP_1_0/lib
    ../Net/uIP_1_0/lib/: memb.c memb.h
  group Net/uIP_1_0/uip
    ../Net/uIP_1_0/uip/: clock.h lc-addrlabels.h lc-switch.h lc.h psock.c psock.h pt.h timer.c timer.h uip-fw.c uip-fw.h uip-neighbor.c uip-neighbor.h uip-split.c uip-split.h uip.c uip.h uip_arch.h uip_arp.c uip_arp.h uiplib.c uiplib.h uipopt.h
  group Net/uIP_1_0/unix
    ../Net/uIP_1_0/unix/: clock-arch.c clock-arch.h tapdev.c tapdev.h uip-conf.h
  group uCOS/core
    ../uCOS/core/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
  group uCOS/iar_port
    ../uCOS/iar_port/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
