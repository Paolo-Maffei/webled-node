# Keil uVision project WifiOpen.uvproj, settings and files
target WifiOpen (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: WifiOpen +hex
  c flags: Optim=1 wLevel=1
  c define: STM32F10X_HD
  c include: ..\Bsp;..\Drivers\FWLib\Inc;..\Drivers\KEY;..\Drivers\Wifi\IF;..\Drivers\Wifi\IO;..\Drivers\Wifi\WLAN;..\Drivers\Wifi\Inc;..\Drivers\Wifi\API;..\Drivers\Wifi\WpaSupplicant;..\Drivers\Wifi\WpaSupplicant\coWPAtty;..\APP;..\Drivers\Wifi\WpaSupplicant\Openssl;..\Include;..\Init;..\Net;..\System;..\Drivers\GSPI;..\Drivers\Buzzer;..\Drivers\Relay;..\Drivers\IntFlash;..\Drivers\LED;..\Drivers\Console;..\Drivers\Uart;..\uCOS\core;..\uCOS\mdk_port;..\Net\uip_1_0\uip;..\Net\uip_1_0\apps\webserver;..\Net\uip_1_0\lib;..\Net\uip_1_0\unix;..\Net\uip_1_0\apps\dhcps;..\Net\uip_1_0\apps\webled_udp;..\APP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group BSP
    ../Bsp/: UartTrace.c core_cm3.c hw_config.c stm32f10x_it.c system_stm32f10x.c
  group STM32FWLib
    ../Drivers/FWLib/src/: stm32f10x_usart.c misc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c
  group Drivers
    ../Drivers/Buzzer/: Buzzer.c
    ../Drivers/Console/: Console.c
    ../Drivers/GSPI/: GSPI.c
    ../Drivers/IntFlash/: Flash.c EEPROM.c
    ../Drivers/LED/: LED.c
    ../Drivers/Relay/: Relay.c
    ../Drivers/Uart/: Uart.c
    ../Drivers/KEY/: KEY.c
  group WifiStack
    ../Drivers/Wifi/Api/: WifiApiExport.c WifiApiPrivate.c WiFiCommand.c
    ../Drivers/Wifi/IF/: Wifi_If.c
    ../Drivers/Wifi/IO/: Wifi_Hw.c
    ../Drivers/Wifi/WLAN/: WlanAdapter.c WlanCmd.c WlanInit.c WlanMisc.c WlanPkt.c
  group uCOS
    ../uCOS/core/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group uCOS_Cpu
    ../uCOS/mdk_port/: os_cpu_c.c os_dbg.c os_cpu_a.asm
  group uIP
    ../Net/uIP_1_0/apps/webserver/: httpd.c httpd-cgi.c httpd-fs.c http-strings.c
    ../Net/uIP_1_0/uip/: psock.c timer.c uip.c uip_arp.c uip-fw.c uiplib.c uip-neighbor.c uip-split.c
    ../Net/uIP_1_0/unix/: clock-arch.c tapdev.c
    ../Net/uIP_1_0/apps/webled_udp/: webled_udp.c
  group Include
    ../Include/: app_cfg.h BaseDefs.h BaseTypes.h OS.h os_cfg.h Project.h WifiCfg.h WifiUser.h
    ../Net/uIP_1_0/uip/: uipopt.h
    ../Net/uIP_1_0/unix/: uip-conf.h
    ../APP/: AppTask.h Group.h uIP_TASK.h
  group APP
    ../APP/: Main.c Group.c AppTask.c uIP_TASK.c module_test.c
  group MDK
    ./: startup_stm32f10x_hd.s
